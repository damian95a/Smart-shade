# Keil uVision project rolata.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rolata
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: LCD_ILI9325
  c include: include;lcd_lib
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c
    ./src/: menu.c MyADC.c MyKeyboard.c MyLCD.c MyRTC.c MyUART.c shade.c
    ./lcd_lib/: asciiLib.c LCD_ILI9325.c Open1768_LCD.c
software components: CMSIS:CORE 5.1.2, CMSIS Driver:USART 2.10.0, Device:GPDMA 1.2.0, Device:PIN 1.0.0, Device:Startup 1.0.0
